DATA SEGMENT
A DB 05H,10H,12H
  DB 50H,90H,03H
B DB 01H,01H,02H
  DB 02H,03H,01H
C DB ?
DATA ENDS

CODE SEGMENT
ASSUME CS:CODE,DS:DATA

START:
MOV AX,DATA
MOV DS,AX

MOV DX,00H
MOV CH,00H

FOR3:
MOV CL,00H

	FOR1:
		LEA SI,A
		ADD SI,DX
		MOV AX,[SI]

		LEA SI,B
		ADD SI,DX
		MOV BX,[SI]

		SUB AX,BX
		LEA SI,C
		ADD SI,DX
		MOV [SI],AX

		INC DX
		INC CL
		CMP CL,02H
		JNE FOR1

INC CH
CMP CH,03H
JNE FOR3


INT 3

CODE ENDS

END START
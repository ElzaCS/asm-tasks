# Keil uVision project doorlock.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: doorlock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: doorlooc.asm
    C:/Keil_v5/C51/LIB/: C51FPL.LIB C51L.LIB

DATA SEGMENT
N DW 8
ANS DW ?
DATA ENDS
CODE SEGMENT
         ASSUME DS:DATA,CS:CODE
START:
MOV AX, DATA
MOV DS, AX

MOV BX, 0
MOV DX, 1
MOV CX, N
LEA SI, ANS
MOV [SI], DX
INC SI

L1:
	ADD BX, DX
	MOV AX, BX
	MOV [SI], AX
	INC SI
	MOV BX, DX
	MOV DX, AX
	DEC CX
	CMP CX, 01
	JNE L1

CODE ENDS
END START